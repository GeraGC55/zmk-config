## config/boards/shields/tubetest/Kconfig.defconfig
```kconfig
if SHIELD_TUBETEST

config ZMK_KEYBOARD_NAME
    default "tubetest"
config ZMK_BLE
	default y

endif
```
